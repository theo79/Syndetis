#include "display.h"
#include "board.h"
#include <stddef.h>
#include <string.h>
#include "driver/i2c_master.h"
#include "esp_log.h"

_Static_assert(OLED_COLUMN_OFFSET >= 0 && OLED_COLUMN_OFFSET <= 4, "SH1106 has 132 columns");
_Static_assert(OLED_ADDRESS == 0 || OLED_ADDRESS == 0x3C || OLED_ADDRESS == 0x3D,
               "Use a 7-bit SH1106 address");
static i2c_master_dev_handle_t device;
static uint8_t address;
static uint8_t framebuffer[DISPLAY_WIDTH * DISPLAY_HEIGHT / 8];

// Original compact 5x7 glyphs, columns stored least-significant pixel first.
static const uint8_t upper[26][5] = {
    {0x7e,0x09,0x09,0x09,0x7e},{0x7f,0x49,0x49,0x49,0x36},
    {0x3e,0x41,0x41,0x41,0x22},{0x7f,0x41,0x41,0x22,0x1c},
    {0x7f,0x49,0x49,0x49,0x41},{0x7f,0x09,0x09,0x09,0x01},
    {0x3e,0x41,0x49,0x49,0x3a},{0x7f,0x08,0x08,0x08,0x7f},
    {0x41,0x41,0x7f,0x41,0x41},{0x20,0x40,0x41,0x3f,0x01},
    {0x7f,0x08,0x14,0x22,0x41},{0x7f,0x40,0x40,0x40,0x40},
    {0x7f,0x02,0x0c,0x02,0x7f},{0x7f,0x04,0x08,0x10,0x7f},
    {0x3e,0x41,0x41,0x41,0x3e},{0x7f,0x09,0x09,0x09,0x06},
    {0x3e,0x41,0x51,0x21,0x5e},{0x7f,0x09,0x19,0x29,0x46},
    {0x26,0x49,0x49,0x49,0x32},{0x01,0x01,0x7f,0x01,0x01},
    {0x3f,0x40,0x40,0x40,0x3f},{0x1f,0x20,0x40,0x20,0x1f},
    {0x3f,0x40,0x38,0x40,0x3f},{0x63,0x14,0x08,0x14,0x63},
    {0x03,0x04,0x78,0x04,0x03},{0x61,0x51,0x49,0x45,0x43},
};
static const uint8_t lower[26][5] = {
    {0x20,0x54,0x54,0x54,0x78},{0x7f,0x48,0x44,0x44,0x38},
    {0x38,0x44,0x44,0x44,0x28},{0x38,0x44,0x44,0x48,0x7f},
    {0x38,0x54,0x54,0x54,0x18},{0x08,0x7e,0x09,0x01,0x02},
    {0x0c,0x52,0x52,0x52,0x3e},{0x7f,0x08,0x04,0x04,0x78},
    {0x00,0x44,0x7d,0x40,0x00},{0x20,0x40,0x44,0x3d,0x00},
    {0x7f,0x10,0x28,0x44,0x00},{0x00,0x41,0x7f,0x40,0x00},
    {0x7c,0x04,0x18,0x04,0x78},{0x7c,0x08,0x04,0x04,0x78},
    {0x38,0x44,0x44,0x44,0x38},{0x7c,0x14,0x14,0x14,0x08},
    {0x08,0x14,0x14,0x18,0x7c},{0x7c,0x08,0x04,0x04,0x08},
    {0x48,0x54,0x54,0x54,0x24},{0x04,0x3f,0x44,0x40,0x20},
    {0x3c,0x40,0x40,0x20,0x7c},{0x1c,0x20,0x40,0x20,0x1c},
    {0x3c,0x40,0x30,0x40,0x3c},{0x44,0x28,0x10,0x28,0x44},
    {0x0c,0x50,0x50,0x50,0x3c},{0x44,0x64,0x54,0x4c,0x44},
};
static const uint8_t digits[10][5] = {
    {0x3e,0x51,0x49,0x45,0x3e},{0x00,0x42,0x7f,0x40,0x00},
    {0x62,0x51,0x49,0x49,0x46},{0x22,0x41,0x49,0x49,0x36},
    {0x18,0x14,0x12,0x7f,0x10},{0x27,0x45,0x45,0x45,0x39},
    {0x3e,0x49,0x49,0x49,0x32},{0x01,0x71,0x09,0x05,0x03},
    {0x36,0x49,0x49,0x49,0x36},{0x26,0x49,0x49,0x49,0x3e},
};

static uint8_t glyph_column(char c, int col)
{
    if (c >= 'A' && c <= 'Z') return upper[c - 'A'][col];
    if (c >= 'a' && c <= 'z') return lower[c - 'a'][col];
    if (c >= '0' && c <= '9') return digits[c - '0'][col];
    // Remaining printable ASCII, so advertised names/punctuation stay readable.
    static const struct { char character; uint8_t columns[5]; } punctuation[] = {
        {'!',{0,0,0x5f,0,0}}, {'"',{0,7,0,7,0}}, {'#',{0x14,0x7f,0x14,0x7f,0x14}},
        {'$',{0x24,0x2a,0x7f,0x2a,0x12}}, {'%',{0x23,0x13,8,0x64,0x62}},
        {'\'',{0,5,3,0,0}}, {'(',{0,0x1c,0x22,0x41,0}}, {')',{0,0x41,0x22,0x1c,0}},
        {'*',{0x14,8,0x3e,8,0x14}}, {'+',{8,8,0x3e,8,8}}, {',',{0,0x50,0x30,0,0}},
        {';',{0,0x56,0x36,0,0}}, {'<',{8,0x14,0x22,0x41,0}}, {'=',{0x14,0x14,0x14,0x14,0x14}},
        {'>',{0,0x41,0x22,0x14,8}}, {'@',{0x32,0x49,0x79,0x41,0x3e}},
        {'[',{0,0x7f,0x41,0x41,0}}, {'\\',{2,4,8,0x10,0x20}}, {']',{0,0x41,0x41,0x7f,0}},
        {'^',{4,2,1,2,4}}, {'_',{0x40,0x40,0x40,0x40,0x40}}, {'`',{0,1,2,4,0}},
        {'{',{0,8,0x36,0x41,0}}, {'|',{0,0,0x7f,0,0}}, {'}',{0,0x41,0x36,8,0}},
        {'~',{8,4,8,0x10,8}},
    };
    for (size_t i = 0; i < sizeof(punctuation) / sizeof(punctuation[0]); ++i)
        if (c == punctuation[i].character) return punctuation[i].columns[col];
    switch (c) {
    case ' ': return 0;
    case '.': return col == 2 ? 0x40 : 0;
    case ':': return col == 2 ? 0x24 : 0;
    case '-': return 0x08;
    case '/': return (uint8_t)(0x40 >> col);
    case '&': { const uint8_t g[] = {0x36,0x49,0x55,0x22,0x50}; return g[col]; }
    default: { const uint8_t g[] = {0x02,0x01,0x51,0x09,0x06}; return g[col]; }
    }
}

static void pixel(int x, int y, bool on)
{
    if (x < 0 || x >= DISPLAY_WIDTH || y < 0 || y >= DISPLAY_HEIGHT) return;
    uint8_t *byte = &framebuffer[(y / 8) * DISPLAY_WIDTH + x];
    if (on) *byte |= 1U << (y % 8);
    else *byte &= ~(1U << (y % 8));
}

void display_clear(void) { memset(framebuffer, 0, sizeof(framebuffer)); }
uint8_t display_address(void) { return address; }

void display_rect(int x, int y, int width, int height, bool filled, bool on)
{
    for (int dy = 0; dy < height; ++dy)
        for (int dx = 0; dx < width; ++dx)
            if (filled || dx == 0 || dy == 0 || dx == width - 1 || dy == height - 1)
                pixel(x + dx, y + dy, on);
}

void display_text(int x, int y, const char *text, int scale, bool on)
{
    for (; *text; ++text, x += 6 * scale)
        for (int col = 0; col < 5; ++col) {
            uint8_t bits = glyph_column(*text, col);
            for (int row = 0; row < 7; ++row)
                if (bits & (1U << row))
                    display_rect(x + col * scale, y + row * scale, scale, scale, true, on);
        }
}

static esp_err_t commands(const uint8_t *bytes, size_t count)
{
    uint8_t packet[32] = {0x00};
    if (count > sizeof(packet) - 1) return ESP_ERR_INVALID_SIZE;
    memcpy(packet + 1, bytes, count);
    return i2c_master_transmit(device, packet, count + 1, 100);
}

esp_err_t display_present(void)
{
    // SH1106 page addressing: do not use SSD1306 horizontal address commands.
    for (int page = 0; page < 8; ++page) {
        const uint8_t pos[] = {0xB0 | page, OLED_COLUMN_OFFSET & 0x0F,
                               0x10 | (OLED_COLUMN_OFFSET >> 4)};
        esp_err_t err = commands(pos, sizeof(pos));
        if (err != ESP_OK) return err;
        uint8_t packet[129] = {0x40};
        memcpy(packet + 1, framebuffer + page * DISPLAY_WIDTH, DISPLAY_WIDTH);
        err = i2c_master_transmit(device, packet, sizeof(packet), 100);
        if (err != ESP_OK) return err;
    }
    return ESP_OK;
}

esp_err_t display_init(void)
{
    i2c_master_bus_handle_t bus;
    const i2c_master_bus_config_t config = {
        .i2c_port = I2C_NUM_0, .sda_io_num = BOARD_SDA, .scl_io_num = BOARD_SCL,
        .clk_source = I2C_CLK_SRC_DEFAULT, .glitch_ignore_cnt = 7,
        .flags.enable_internal_pullup = true,
    };
    esp_err_t err = i2c_new_master_bus(&config, &bus);
    if (err != ESP_OK) return err;
    int found = 0;
    for (uint8_t candidate = 0x3C; candidate <= 0x3D; ++candidate) {
        if (OLED_ADDRESS && candidate != OLED_ADDRESS) continue;
        err = i2c_master_probe(bus, candidate, 100);
        if (err == ESP_OK) { address = candidate; ++found; }
        else if (err != ESP_ERR_NOT_FOUND) return err;
    }
    if (found != 1) {
        ESP_LOGE("display", "Expected one OLED ACK, got %d. Check wiring/address in board.h", found);
        return ESP_ERR_NOT_FOUND;
    }
    ESP_LOGI("display", "OLED ACK verified at 7-bit address 0x%02X", address);
    const i2c_device_config_t dev_config = {
        .dev_addr_length = I2C_ADDR_BIT_LEN_7, .device_address = address,
        .scl_speed_hz = OLED_I2C_HZ,
    };
    err = i2c_master_bus_add_device(bus, &dev_config, &device);
    if (err != ESP_OK) return err;
    const uint8_t init[] = {
        0xAE, 0xD5, 0x80, 0xA8, 0x3F, 0xD3, 0x00, 0x40,
        OLED_ROTATE_180 ? 0xA0 : 0xA1, OLED_ROTATE_180 ? 0xC0 : 0xC8,
        0xDA, 0x12, 0x81, 0x80, 0xD9, 0x22, 0xDB, 0x35,
        0xAD, 0x8B, 0xA4, 0xA6,
    };
    err = commands(init, sizeof(init));
    if (err != ESP_OK) return err;
    // Clear all 132 RAM columns, including those outside the visible glass.
    for (int page = 0; page < 8; ++page) {
        const uint8_t pos[] = {0xB0 | page, 0x00, 0x10};
        err = commands(pos, sizeof(pos));
        if (err != ESP_OK) return err;
        uint8_t blank[133] = {0x40};
        err = i2c_master_transmit(device, blank, sizeof(blank), 100);
        if (err != ESP_OK) return err;
    }
    const uint8_t on[] = {0xAF};
    return commands(on, sizeof(on));
}
